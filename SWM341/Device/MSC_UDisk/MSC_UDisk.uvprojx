# Keil uVision project MSC_UDisk.uvprojx, settings and files
target SWM341 (6160000::V6.16::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.2.2.7
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: MSC_UDisk
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2 v6Lang=3 v6LangP=1 wLevel=3
  c define: SW_LOG_LEVEL = 3
  c include: ..\..\..\..\SWM341_Lib\SWM341_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\..\..\SWM341_Lib\SWM341_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\..\..\SWM341_Lib\SWM341_StdPeriph_Driver\CSL\SWM341_StdPeriph_Driver;..\..\..\..\CherryUSB\core;..\..\..\..\CherryUSB\common;..\..\..\..\CherryUSB\class\msc;.\APP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./APP/: main.c msc_flash.c FlashDisk.c
  group CSL\StdPD
    ../../../../SWM341_Lib/SWM341_StdPeriph_Driver/CSL/SWM341_StdPeriph_Driver/: SWM341_flash.c SWM341_gpio.c SWM341_port.c SWM341_timr.c SWM341_uart.c SWM341_usbd.c SWM341_sfc.c SWM341_sdram.c
  group CSL\CMSIS
    ../../../../SWM341_Lib/SWM341_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM341.c
    ../../../../SWM341_Lib/SWM341_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM341.s
  group CherryUSB
    ../../../../CherryUSB/core/: usbd_core.c
    ../../../../CherryUSB/port/swm341/: usb_dc_swm341.c
    ../../../../CherryUSB/class/msc/: usbd_msc.c
