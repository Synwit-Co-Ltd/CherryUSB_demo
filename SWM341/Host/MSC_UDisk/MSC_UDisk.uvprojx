# Keil uVision project MSC_UDisk.uvprojx, settings and files
target SWM341 (6160000::V6.16::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.2.2.5
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: MSC_UDisk
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2 v6Lang=3 v6LangP=1 wLevel=3
  c define: SW_LOG_LEVEL = 3
  c include: ..\..\..\..\SWM341_Lib\SWM341_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\..\..\SWM341_Lib\SWM341_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\..\..\SWM341_Lib\SWM341_StdPeriph_Driver\CSL\SWM341_StdPeriph_Driver;..\..\..\..\CherryUSB\core;..\..\..\..\CherryUSB\common;..\..\..\..\CherryUSB\class\msc;..\..\..\..\CherryUSB\class\hub;..\..\..\..\CherryUSB\third_party\fatfs-0.14\source;..\..\..\..\CherryUSB\third_party\FreeRTOS-10.4\include;.\APP;..\..\..\..\CherryUSB\third_party\FreeRTOS-10.4\portable\GCC\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./APP/: main.c usb_host.c
  group FatFs
    ../../../../CherryUSB/third_party/fatfs-0.14/source/: ff.c ffsystem.c ffunicode.c diskio.c
    ./APP/: usbh_fatfs.c
  group FreeRTOS
    ../../../../CherryUSB/third_party/FreeRTOS-10.4/: list.c queue.c tasks.c timers.c event_groups.c
    ../../../../CherryUSB/third_party/FreeRTOS-10.4/portable/MemMang/: heap_4.c
    ../../../../CherryUSB/third_party/FreeRTOS-10.4/portable/GCC/ARM_CM3/: port.c
    ../../../../CherryUSB/osal/: usb_osal_freertos.c
  group CSL\StdPD
    ../../../../SWM341_Lib/SWM341_StdPeriph_Driver/CSL/SWM341_StdPeriph_Driver/: SWM341_flash.c SWM341_gpio.c SWM341_port.c SWM341_timr.c SWM341_uart.c SWM341_usbd.c SWM341_sfc.c SWM341_sdram.c
  group CSL\CMSIS
    ../../../../SWM341_Lib/SWM341_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM341.c
    ../../../../SWM341_Lib/SWM341_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM341.s
  group CherryUSB
    ../../../../CherryUSB/core/: usbh_core.c
    ../../../../CherryUSB/class/msc/: usbh_msc.c
    ../../../../CherryUSB/class/hub/: usbh_hub.c
    ../../../../CherryUSB/port/swm341/: usb_hc_swm341.c
